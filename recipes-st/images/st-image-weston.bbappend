IMAGE_INSTALL:append = " netbridge-udev-init"
IMAGE_INSTALL:append = " hello-world"
IMAGE_INSTALL:append = " button-detect"
IMAGE_INSTALL:append = " break-out"