IMAGE_INSTALL:append = " hello-world"
IMAGE_INSTALL:append = " button-detect"
IMAGE_INSTALL:append = " tft-tester"